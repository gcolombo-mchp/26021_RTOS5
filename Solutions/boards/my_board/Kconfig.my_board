## Solutions/boards/my_board/board.yml
```yaml
board:
  name: my_board
  full_name: My Board
  vendor: My_Self
  socs:
    - name: same54p20a
```
