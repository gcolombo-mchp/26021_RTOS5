## Solutions/boards/microchip/same54_cult/board.yml
```yaml
board:
  name: same54_cult
  full_name: SAM E54 Curiosity Utra
  vendor: atmel
  socs:
    - name: same54p20a
```
